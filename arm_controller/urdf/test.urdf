Commit message: created urdf directory for new work, got the robotics toolbox solver accepting urdf

File: arm_controller/urdf/test.urdf (robot description, URDF)
Before this commit: robot test_robot, 4 links, 3 joints
Joints:
- joint joint2: parent link1 -> link2
