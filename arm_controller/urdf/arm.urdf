Commit message: fixed shoulder axis issue

File: arm_controller/urdf/arm.urdf (robot description, URDF)
Before this commit: robot MechaArm, 10 links, 9 joints
Joints:
- joint shoulder: axis 0 1 0 -> 0 -1 0; origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0 rpy=0 2.87979 0
